# Keil uVision project kitchen_Safety_Monitoring.uvproj, settings and files
target LPC2148 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Safety_Monitoring +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup
    ./: Startup.s display_name.c
  group tiimer
    ./: timer0_delay.c
  group LCD
    ./: LCD.c
  group RTC
    ./: RTC.c
  group Sensor
    ./: LM35.c LED_Buzzer.c ADC_LPC2148.c
  group keypad
    ./: KPM.c
  group Main
    ./: Event_log.c main1.c
  group interrupt
    ./: security.c eint0.c
